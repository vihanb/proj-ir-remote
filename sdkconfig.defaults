## sdkconfig.defaults
```kconfig
CONFIG_BT_ENABLED=y
CONFIG_BTDM_CTRL_MODE=BTDM_CTRL_MODE_BLE_ONLY
CONFIG_BT_HOST=BT_NIMBLE_ENABLED
```
